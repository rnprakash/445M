# Keil uVision project RTOS.uvproj, settings and files
target RTOS811 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS811
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: Startup.s user.c osasm.s os.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
