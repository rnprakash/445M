# Keil uVision project Lab2.uvproj, settings and files
target OLED (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED
  c flags: Optim=1
  c include: ..;..\..\..;..\driverlib;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./: Startup.s Output.c rit128x96x4.c OS_Critical.c shell.c UART.c osasm.s PID_stm32.s cr4_fft_64_stm32.s ADC.h OS_Buttons.c OS_DataStructures.c OS_Threads.c OS_Time.c OS.c Lab4Main.c Lab2Main.c ADC.c sqrt.c edisk.c Lab5.c eFile.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
