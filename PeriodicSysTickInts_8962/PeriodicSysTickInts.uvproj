# Keil uVision project PeriodicSysTickInts.uvproj, settings and files
target PeriodicSysTickInts (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PeriodicSysTickInts
  c flags: Optim=4
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s PeriodicSysTickInts.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
