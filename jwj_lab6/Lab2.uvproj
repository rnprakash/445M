# Keil uVision project Lab2.uvproj, settings and files
target Lab2 (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab2
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./: Startup.s UART2.c OS.c OS.h OSasm.s edisk.c eFile.c Interperter.c Lab5.c PingMeasure.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
