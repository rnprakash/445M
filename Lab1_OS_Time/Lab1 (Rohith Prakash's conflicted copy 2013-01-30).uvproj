# Keil uVision project Lab1 (Rohith Prakash's conflicted copy 2013-01-30).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab1
  c flags: Optim=1
  c include: ..;..\..\..;..\driverlib;..\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Startup.s OS.c OS_Critical.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
